FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

SRC_URI += " \
    file://UefiDefaultSecurityKeys.dts \
"
