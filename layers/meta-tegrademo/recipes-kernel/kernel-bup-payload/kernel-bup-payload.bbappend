inherit digsigserver-tegra-signing
